options:
  parameters:
    author: baldo
    generate_options: no_gui
    id: collector
    output_language: python
    title: collector
  states: {}

blocks:
- name: cent_freq
  id: variable
  parameters:
    value: '5210000000'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: 2*4*20000
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '80000000'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '6000'
    psize: payload_size
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '6003'
    psize: payload_size
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '6001'
    psize: payload_size
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '6002'
    psize: payload_size
    type: complex
    vlen: '1'
  states: {}
- name: pfb_channelizer_hier_ccf_0
  id: pfb_channelizer_hier_ccf
  parameters:
    atten: '100'
    bw: '1.0'
    n_filterbanks: '4'
    nchans: '4'
    outchans: None
    ripple: '0.1'
    taps: None
    tb: '0.2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: cent_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [pfb_channelizer_hier_ccf_0, '0', blocks_udp_sink_0, '0']
- [pfb_channelizer_hier_ccf_0, '1', blocks_udp_sink_0_0_0, '0']
- [pfb_channelizer_hier_ccf_0, '2', blocks_udp_sink_0_0_0_0, '0']
- [pfb_channelizer_hier_ccf_0, '3', blocks_udp_sink_0_0, '0']
- [uhd_usrp_source_0, '0', pfb_channelizer_hier_ccf_0, '0']

metadata:
  file_format: 1
